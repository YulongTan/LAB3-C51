# Keil uVision project test3.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F310 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: test3
  c flags: Optimize=8 SizeSpeed=1
  asm include: ..\test3
  group Source Group 1
    ./: test3.a51
